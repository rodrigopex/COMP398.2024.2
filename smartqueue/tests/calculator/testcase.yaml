## smartqueue/tests/calculator/testcase.yaml
```yaml
tests:
  smartqueue.calc_unittests:
    integration_platforms:
      - qemu_cortex_m3
```
